# IAR project babyLove.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L476RG ST STM32L476RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L476xx; USE_HAL_DRIVER; USE_STM32L4XX_NUCLEO; STM32_SENSORTILE
  ICCARM.CCIncludePath2: Inc; ..\..\..\..\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\Middlewares\ST\STM32_BlueNRG\SimpleBlueNRG_HCI\includes; ..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\Drivers\BSP\Components\lsm6dsm; ..\..\..\..\Drivers\BSP\Components\lps25hb; ..\..\..\..\Drivers\BSP\Components\lsm6ds3; ..\..\..\..\Drivers\BSP\Components\lis3mdl; ..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\Drivers\BSP\Components\lps22hb; ..\..\..\..\Drivers\BSP\Components\lsm303agr; ..\..\..\..\Drivers\BSP\SensorTile; ..\..\..\..\Middlewares\ST\STM32_OSX_MotionFX_Library\Inc; ..\..\..\..\Middlewares\ST\STM32_OSX_MotionAR_Library\Inc; ..\..\..\..\Middlewares\ST\STM32_OSX_MotionCP_Library\Inc; ..\..\..\..\Middlewares\ST\STM32_OSX_MotionGR_Library\Inc; ..\..\..\..\Middlewares\ST\STM32_OSX_BlueVoice_Library\Inc; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32L4xx\Include; ..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\..\..\Drivers\BSP\Components\stc3115; ..\..\..\..\Middlewares\ST\STM32_MetaDataManager; ..\..\..\..\Drivers\BSP\Components\pcm1774
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: babyLove.hex
  ILINK.IlinkOutputFile: babyLove.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32l476xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group babyLove/IAR
    ./: startup_stm32l476xx.s
  group babyLove/User
    Src/: AudioBV_Manager.c HWAdvanceFeatures.c main.c MotionAR_Manager.c MotionCP_Manager.c MotionFX_Manager.c MotionGR_Manager.c OTA.c sensor_service.c stm32l4xx_hal_msp.c stm32l4xx_it.c TargetPlatform.c usbd_cdc_interface.c usbd_conf.c usbd_desc.c
  group Doc
    ./: readme.txt
  group Drivers/BSP/Components
    ../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
    ../../../../Drivers/BSP/Components/lsm6dsm/: LSM6DSM_ACC_GYRO_driver.c LSM6DSM_ACC_GYRO_driver_HL.c
    ../../../../Drivers/BSP/Components/stc3115/: STC3115_Driver.c
  group Drivers/BSP/SensorTile
    ../../../../Drivers/BSP/SensorTile/: SensorTile.c SensorTile_accelero.c SensorTile_audio_in.c SensorTile_BlueNRG.c SensorTile_gg.c SensorTile_gyro.c SensorTile_humidity.c SensorTile_magneto.c SensorTile_pressure.c SensorTile_sd.c SensorTile_temperature.c
  group Drivers/CMSIS
    Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx-Nucleo
    ../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_ll_usb.c
  group Middlewares/MetaDataManager
    ../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Middlewares/OSX
    ../../../../Middlewares/ST/STM32_OSX_BlueVoice_Library/Lib/: osxBlueVoice200_CM4F_IAR_ot.a
    ../../../../Middlewares/ST/STM32_OSX_MotionAR_Library/Lib/: osxMotionAR120_CM4F_IAR_ot.a
    ../../../../Middlewares/ST/STM32_OSX_MotionCP_Library/Lib/: osxMotionCP100_CM4F_IAR_ot.a
    ../../../../Middlewares/ST/STM32_OSX_MotionFX_Library/Lib/: osxMotionFX107_CM4_IAR_ot.a
    ../../../../Middlewares/ST/STM32_OSX_MotionGR_Library/Lib/: osxMotionGR100_CM4F_IAR_ot.a
  group Middlewares/STM32_BlueNRG
    ../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/utils/: ble_list.c gp_timer.c osal.c
    ../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_utils.c
    ../../../../Middlewares/ST/STM32_BlueNRG/Interface/: bluenrg_itf_template.c
    ../../../../Middlewares/ST/STM32_BlueNRG/SimpleBlueNRG_HCI/hci/: hci.c
  group Middlewares/STM32_USBD_Library
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
